# Keil uVision project stm32f407_xiangmu.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_xiangmu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Start;.\Library\inc;.\Library\src;.\Driver\inc;.\Driver\src;.\System;.\FreeModbus\ascii;.\FreeModbus\BARE\port;.\FreeModbus\include;.\FreeModbus\rtu;.\FreeModbus\tcp;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\GUI;.\GUI\lvgl;.\GUI\lvgl_driver;.\GUI\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group System
    ./System/: system.c system.h SysTick.c SysTick.h
  group Start
    ./Start/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c
  group Library/inc
    ./Library/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Library/src
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeModbus_core
    ./FreeModbus/ascii/: mbascii.c
    ./FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./FreeModbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/tcp/: mbtcp.c
    ./FreeModbus/: mb.c
  group FreeModbus_port
    ./FreeModbus/BARE/port/: portevent.c portserial.c porttimer.c
  group FreeModbus_app
    ./Driver/src/: mb_app.c
  group FreeRTOS_core
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Driver
    ./Driver/src/: led.c tftlcd.c key.c beep.c usart.c i2c.c step_motor.c adc.c time.c 24cxx.c wdt.c
    ./Driver/inc/: 24cxx.h wdt.h
  group App
    ./Driver/inc/: task_motor.h task_adc.h task_protect.h task_param.h task_gui.h
    ./Driver/src/: task_motor.c task_adc.c task_protect.c task_param.c task_gui.c
  group GUI
    ./GUI/: lv_conf.h
    ./GUI/lvgl/: lvgl.h
    ./GUI/lvgl_driver/: lv_port_disp.h lv_port_disp.c
    ./GUI/app/: lv_app.h lv_app.c font_cn_16.c font_cn_24.c
    ./GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ./GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ./GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./GUI/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ./GUI/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite.c lv_vglite_buf.c lv_vglite_utils.c
    ./GUI/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./GUI/lvgl/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ./GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./GUI/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ./GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./GUI/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./GUI/lvgl/src/extra/: lv_extra.c
    ./GUI/lvgl/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ./GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ./GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ./GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ./GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./GUI/lvgl/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ./GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ./GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ./GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ./GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ./GUI/lvgl/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ./GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./GUI/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ./GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
